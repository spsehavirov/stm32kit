# Keil uVision project STM32_L152RE.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00014000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_L152RE
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group examples
    ../../../: README.md
    ../../../examples/: example_01-blinkLED.c example_02-extLED.c example_03-userButton.c example_04-LCD.c example_05-KeyPad.c example_06-blinkLED_TIMx.c example_07-blinkLED_TIMx-2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.0.0
