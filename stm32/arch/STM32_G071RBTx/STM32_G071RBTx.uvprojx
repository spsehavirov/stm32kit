# Keil uVision project STM32_G071RBTx.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32_G071RBTx
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group examples
    ../../../: README.md
    ../../../examples/: example_01-blinkLED.c example_02-extLED.c example_03-userButton.c example_04-LCD.c example_05-KeyPad.c example_06-blinkLED_TIMx.c example_07-blinkLED_TIMx-2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
