# Keil uVision project STM32_F411RETx.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F411RETx
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STM32_ALL_src
    ../STM32_ALL_src/: STM32_00_HelloWorld_01-blinkLED.c STM32_00_HelloWorld_02-extLED.c STM32_00_HelloWorld_03-userButton.c STM32_00_HelloWorld_04-LCD.c STM32_00_HelloWorld_05-KeyPad.c
    ../: README.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
